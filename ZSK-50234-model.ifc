Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:18:47+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcProject, ОРИОН ZSK-50234
Classification: Классификатор строительных ресурсов (КСР)

# IfcFurnishingElement: Оборудование благоустройства, ZSK-50234 Тематический игровой комплекс «Маяк»
In: Площадка
Description: Оборудование благоустройства. Тематический игровой комплекс «Маяк»; Classification: 59.1.15.01-0532 Комплекс игровой (Классификатор строительных ресурсов (КСР))
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-50234; ModelReference: Тематический игровой комплекс «Маяк»; ProductionYear: 2026; ArticleNumber: ZSK-50234
ORION_Изделие - Артикул: ZSK-50234; Артикул прежний: SD-50234; Наименование: Тематический игровой комплекс «Маяк»; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: 7.7 x 7.4 м; Зона безопасности: 12.70 x 12.40 м; Высота свободного падения: 3.0 м; Возраст: для детей от 5 до 12 лет; Цена: 6 041 040 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/themed/3003; Код КСИ: CPr>EDB080; Класс КСИ: Комплекс игровой; Коды КСР: 59.1.15.01-0532 … 59.1.15.01-0595
ADSK - ADSK_Наименование: Тематический игровой комплекс «Маяк»; ADSK_Марка: ZSK-50234; ADSK_Код изделия: 59.1.15.01-0532; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_URL страницы изделия: https://зск.рф/catalog/themed/3003
ZSK_Благоустройство - ZSK_Возрастная_группа: для детей от 5 до 12 лет; ZSK_Зона_безопасности: 12.70 x 12.40 м; ZSK_Высота_свободного_падения: 3.0 м; ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDB080; ZSK_Артикул_прежний: SD-50234
Qto_ORION - Длина: 7700 mm; Ширина: 7400 mm; Высота: 0 mm
